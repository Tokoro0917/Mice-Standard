# Repository Tokoro0917/Mice-Standard

File README.md:

# Mice-Standard

東京理科大学 Mice の **マイクロマウス標準機（クラシック）** をまとめたリポジトリです。
新入部員が「はんだ付けして、プログラムを書いて、走らせる」までを一通り体験できることを目指しています。

## 構成

| ディレクトリ | 内容 | ツール |
| --- | --- | --- |
| [`docs/`](docs/) | 環境構築、組み立て、はんだ付けの手順書 | Markdown |
| [`hardware/`](hardware/) | 回路図・基板データ | KiCad |
| [`mechanical/`](mechanical/) | 機構設計データ、3Dプリント・加工用データ | Fusion 360 |
| [`firmware/`](firmware/) | マイコンのプログラム | STM32CubeMX + VS Code |
| [`tools/`](tools/) | PC 側の補助ツール（ログ可視化など） | — |

## はじめかた

1. [開発環境の構築](docs/getting-started.md)
2. [はんだ付け](docs/soldering/README.md)
3. [組み立て](docs/assembly/README.md)
4. [プログラムを書き込んで動かす](firmware/README.md)

> 基板はサークルでまとめて発注します。部員の作業は **はんだ付けから** です。

## 仕様

| 項目 | 値 |
| --- | --- |
| 競技 | クラシック（18 cm 区画） |
| モータ | ステッピングモータ PKP242D23A2 ×2 |
| マイコン | NUCLEO-L432KC |
| モータドライバ | MP6500 モジュール ×2 |
| センサ | 赤外 LED + フォトトランジスタ ×4 組 |
| 電源 | LiPo 3 セル、P-ch MOSFET の電源スイッチ（KOGUMA-Mk4 方式）、9 V LDO で NUCLEO の VIN・壁センサ LED・ブザーに給電 |
| 寸法・重量 | TBD |

詳しくは [仕様書](docs/spec.md) を参照してください。

## バージョン

歴代の機体は残さず、**現行の標準機のみ** を管理します。
基板・機構・ファームの対応は Git のタグ（`v1.0` など）でそろえます。

## ライセンス

| 対象 | ライセンス |
| --- | --- |
| `firmware/`、`tools/`（プログラム） | [MIT License](LICENSE-MIT) |
| `hardware/`、`mechanical/`、`docs/` など（基板・CAD・文書） | [CC BY 4.0](LICENSE-CC-BY-4.0) |

どちらも「東京理科大学 Mice」のクレジットを書けば、改造・再配布・商用利用が可能です。
STM32CubeMX が生成するコードや、第三者のライブラリ・部品データは、それぞれ元のライセンスに従います。詳しくは [LICENSE](LICENSE) を参照してください。

## KiCad design hardware/main-board/mice-standard.kicad_pcb

File hardware/README.md:

# hardware

KiCad の回路図・基板データです。

| ディレクトリ | 内容 |
| --- | --- |
| `main-board/` | メイン基板の KiCad プロジェクト `mice-standard`（回路図 A3 1 枚 + 基板）。`mice-standard.pdf` は KiCad なしで見られる回路図 |
| `sensor-board/` | センサ基板の KiCad プロジェクト（赤外 LED + フォトトランジスタ 1 組）。1 台に 4 枚使い、メイン基板の J10〜J13 のスリットに差し込んではんだ付けする |
| `lib/` | 自作フットプリント `Mice-Standard.pretty`（センサのスリット・タブ、スライドスイッチ、圧電サウンダ） |
| `production/` | 発注用データ（ガーバー、BOM、部品配置）。リリースごとに更新 |

基板は役員がまとめて発注します。部員ははんだ付けの際に `production/` の BOM を参照してください。

## 回路図 v0.1 について

- KiCad 7 形式で作成。KiCad 8 以降（10 を含む）で開くと新しい形式に自動変換される
- フットプリントは未設定（基板設計の段階で割り当てる）
- MP6500 のピンの並びは確認済み（`docs/spec.md`「モータドライバ（MP6500）の接続」）
- 要確認: モータ線と XH コネクタのピン対応

## 基板設計 v0.3（配置まで、配線は未着手）

### メイン基板（80 × 100 mm、JLCPCB の 100 × 100 mm 以内、配置図 `main-board/placement.png`）

- モータの上に水平に載せる。前（センサ側）が上。車軸は前端から 55 mm
- 幅 80 mm（車幅 80 mm）: ホイールの上・外側まで基板を伸ばした（ホイールの上端 47 mm < 基板の下面 48.5 mm）。ホイールより外側の帯（左右 約 7 mm）も部品に使える。ホイールの上（|X| 26〜33 mm、車軸の前後 ±23.5 mm）には部品を置かない（足が当たるため）
- 壁センサのスリットは KOGUMA-Mk4 と同じ考え方で配置（`docs/spec.md`「壁センサの配置」）
- 配置: 前端に壁センサのスリット 4 つ、中央に NUCLEO（下に背の低い抵抗）、左右の帯にモータのコネクタ・表示 LED・スイッチ・ブザー、後ろに MP6500 ×2 と電源。MP6500 は NUCLEO 本体（ピンソケットより前後に長い）と重ならない位置
- 取付穴 M3 ×4（3D プリントの台に固定）

### センサ基板（12 × 30 mm + 差し込み部 8.6 × 2.5 mm）

- メイン基板の下に垂れ下がる向きに差し込み、差し込み部の先をメイン基板の上面ではんだ付けする
- 表のパッド（LED A / K）はスリットの矢印側、裏のパッド（PT C / E）は反対側と合わせる

### 要確認・これから

- 配線（未着手）
- 自作フットプリントの寸法（スライドスイッチの穴径、圧電サウンダの端子間隔）を現物で確認
- NUCLEO の USB の向きとピンソケット（CN3 / CN4）の左右
- 33 Ω 1 W 抵抗の大きさ（DIN0207 で仮置き）

Parts:
BZ1: PKM13EPYH4000-A0 (他励); Buzzer_Murata_PKM13EPYH4000
C1, C2, C4, C5: 100µF 25V; CP_Radial_D5.0mm_P2.00mm
C3, C6: 0.1µF; C_Disc_D3.0mm_W1.6mm_P2.50mm
D1, D2, D3, D4: 赤 OS5RKA3131A; LED_D3.0mm
J1: XT30 (電池 LiPo 3S); AMASS_XT30U-F_1x02_P5.0mm_Vertical
J2: NUCLEO CN3; PinSocket_1x15_P2.54mm_Vertical
J3: NUCLEO CN4; PinSocket_1x15_P2.54mm_Vertical
J4: MP6500 L 左列; PinSocket_1x08_P2.54mm_Vertical
J5: MP6500 L 右列; PinSocket_1x08_P2.54mm_Vertical
J6: MP6500 R 左列; PinSocket_1x08_P2.54mm_Vertical
J7: MP6500 R 右列; PinSocket_1x08_P2.54mm_Vertical
J8: XH 4P (左モータ); JST_XH_B4B-XH-A_1x04_P2.50mm_Vertical
J9: XH 4P (右モータ); JST_XH_B4B-XH-A_1x04_P2.50mm_Vertical
J10: センサ基板 左横 LS; SensorSlot_4P
J11: センサ基板 左前 LF; SensorSlot_4P
J12: センサ基板 右前 RF; SensorSlot_4P
J13: センサ基板 右横 RS; SensorSlot_4P
Q1, Q2, Q4: SS8050-D; TO-92_Inline
Q3: 2SJ673-AZ (電源スイッチ); TO-220F-3_Vertical
R1, R19, R20: 10k; R_Axial_DIN0204_L3.6mm_D1.6mm_P7.62mm_Horizontal
R2, R3, R4, R13, R14, R15, R16, R17, R18: 2.2k; R_Axial_DIN0204_L3.6mm_D1.6mm_P7.62mm_Horizontal
R5, R7: 100 (Rb); R_Axial_DIN0204_L3.6mm_D1.6mm_P7.62mm_Horizontal
R6, R8: 33Ω 1W (Re); R_Axial_DIN0207_L6.3mm_D2.5mm_P10.16mm_Horizontal
R9, R10, R11, R12: 2.2k (RL); R_Axial_DIN0204_L3.6mm_D1.6mm_P7.62mm_Horizontal
SW1: SS-12D00G3 (電源); SW_Slide_SS-12D00G3
SW2: タクトスイッチ (SW1); SW_PUSH_6mm
SW3: タクトスイッチ (SW2); SW_PUSH_6mm
U1: BA90DD0T (9V LDO); TO-220F-3_Vertical

Connections:
+3V3: J3.14, J4.2, J4.3, J6.2, J6.3, J10.3, J11.3, J12.3, J13.3, R3.1, R4.1
+9V: BZ1.1 (+), C5.1, J3.1, J10.1, J11.1, R18.1, U1.3 (OUT)
+BATT: C1.1, C2.1, C4.1, J5.1, J7.1, Q3.2 (D), R1.1, U1.1 (IN)
/BAT_IN: C6.1, J1.1, Q3.3 (S), R19.1
/BUZZER: J3.7, R17.1
/BZ_N: BZ1.2 (-), Q4.3 (C), R18.2
/DIR_L: J2.5, J4.8
/DIR_R: J2.6, J6.8
/IRF_C: J12.2, Q2.3 (C)
/IRF_E: Q2.1 (E), R8.1
/IRF_M: J11.2, J12.1
/IRLED_FRONT: J2.14, R7.1
/IRLED_SIDE: J2.13, R5.1
/IRS_C: J13.2, Q1.3 (C)
/IRS_E: Q1.1 (E), R6.1
/IRS_M: J10.2, J13.1
/LED1: J3.15, R13.2
/LED1_A: D1.2 (A), R13.1
/LED2: J2.1, R14.2
/LED2_A: D2.2 (A), R14.1
/LED3: J2.7, R15.2
/LED3_A: D3.2 (A), R15.1
/LED4: J2.8, R16.2
/LED4_A: D4.2 (A), R16.1
/ML_A1: J5.5, J8.1
/ML_A2: J5.6, J8.2
/ML_B1: J5.4, J8.3
/ML_B2: J5.3, J8.4
/MOTOR_EN: J2.9, J4.1, J6.1
/MR_A1: J7.5, J9.1
/MR_A2: J7.6, J9.2
/MR_B1: J7.4, J9.3
/MR_B2: J7.3, J9.4
/PGATE: C6.2, Q3.1 (G), R19.2, R20.1
/SENS_LF: J3.11, J11.4, R10.1
/SENS_LS: J3.12, J10.4, R9.1
/SENS_RF: J3.10, J12.4, R11.1
/SENS_RS: J3.9, J13.4, R12.1
/SLEEP_L: J4.6, R3.2
/SLEEP_R: J6.6, R4.2
/STEP_L: J2.12, J4.7
/STEP_R: J3.8, J6.7
/SW1: J2.15, SW2.1
/SW2: J2.2, SW3.1
/SW_G: R20.2, SW1.2 (B)
/VBAT_SENSE: C3.1, J3.6, R1.2, R2.1
GND: C1.2, C2.2, C3.2, C4.2, C5.2, D1.1 (K), D2.1 (K), D3.1 (K), D4.1 (K), J1.2, J2.4, J3.2, J4.4, J4.5, J5.2, J5.8, J6.4, J6.5, J7.2, J7.8, Q4.1 (E), R2.2, R6.2, R8.2, R9.2, R10.2, R11.2, R12.2, SW1.1 (A), SW2.2, SW3.2, U1.2 (GND)
unnamed: Q1.2 (B), R5.2
unnamed: Q2.2 (B), R7.2
unnamed: Q4.2 (B), R17.2

Notes on the sheet:
ON: SW1 で R20 を GND へ → VGS = −VBAT/2 (約 −5.4〜−6.3 V)。C6 で約 0.5 ms かけて ON
C1, C2: 各 MP6500 の VMOT の近くに置く
電池電圧の分圧 (12.6 V → 2.27 V)
マイコン NUCLEO-L432KC (ピンソケットに差し込み)
※ SB16 / SB18 を外して使う (D4 / D5 を LED3 / LED4 に使うため)
D1 PA9
D0 PA10
RESET
GND
D2 PA12
D3 PB0
D4 PB7
D5 PB6
D6 PB1
D7 PC14 (LSE)
D8 PC15 (LSE)
D9 PA8 TIM1_CH1
D10 PA11
D11 PB5
D12 PB4
VIN
+5V
A7 PA2 (VCP_TX)
A6 PA7 ADC_IN12
A5 PA6 TIM16_CH1
A4 PA5 TIM2_CH1
A3 PA4 ADC_IN9
A2 PA3 ADC_IN8
A1 PA1 ADC_IN6
A0 PA0 ADC_IN5
AREF
+3V3
D13 PB3 (LD3)
モータドライバ MP6500 デジタル電流制御版 ×2 (ピンソケットに差し込み)
I1 = I2 = L で電流制限 2 A。MS1 = MS2 = H で 1/8 ステップ
ピンの並びは Pololu の配線図・裏面写真で確認済み (上から見て左列 ENBL〜DIR、右列 VMOT〜GND)
左モータ
ENBL
VMOT
MS1

Board: 2 copper layers, 56 parts (0 on the bottom side), 50 nets, no tracks yet.

Other parts of the board:
H1, H2, H3, H4: M3; MountingHole_3.2mm_M3

## KiCad design hardware/sensor-board/sensor-board.kicad_pcb

Parts:
D1: OSI5LA5A33A-B (赤外 940 nm); LED_D5.0mm
J1: 差し込み部 (タブ); SensorTab_4P
Q1: L-51ROPT1D1; LED_D5.0mm

Connections:
/LED_A: D1.2 (A), J1.1
/LED_K: D1.1 (K), J1.2
/PT_C: J1.3, Q1.1 (C)
/PT_E: J1.4, Q1.2 (E)

Notes on the sheet:
センサ基板 (1 台に 4 枚、メイン基板の J10〜J13 に差し込んではんだ付け)
差し込み部 J1: 表 1 = LED A / 2 = LED K、裏 3 = PT C / 4 = PT E。LED とフォトトランジスタは表 (壁を見る側) に付ける
LED は 2 枚ずつ直列 (横 2 枚、前 2 枚) でメイン基板の定電流回路につながる。受光の RL 2.2 kΩ はメイン基板
フォトトランジスタは短い足がコレクタ (C)

Board: 2 copper layers, 3 parts (0 on the bottom side), 4 nets, no tracks yet.
